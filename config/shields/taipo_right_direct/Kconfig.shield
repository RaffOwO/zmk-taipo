## config/shields/taipo_right_direct/Kconfig.shield
```kconfig
config SHIELD_TAIPO_RIGHT_DIRECT
    def_bool $(shields_list_contains,taipo_right_direct)
```
